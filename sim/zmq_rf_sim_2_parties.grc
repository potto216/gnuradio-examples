options:
  parameters:
    generate_options: qt_gui
    id: byte_rf_sim
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: amp
  id: variable
  parameters:
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '.5'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_CONST_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '34'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: byte
    waveform: analog.GR_CONST_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '4'
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '0'
    type: byte
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: '0'
    type: byte
  states: {}
- name: blocks_delay_0_0_0
  id: blocks_delay
  parameters:
    delay: '0'
    type: byte
  states: {state: disabled}
- name: blocks_msgpair_to_var_0
  id: blocks_msgpair_to_var
  parameters:
    target: amp
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pack_k_bits_bb_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pack_k_bits_bb_0_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_packed_to_unpacked_xx_0_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_packed_to_unpacked_xx_0_0_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_throttle2_0_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {state: disabled}
- name: blocks_uchar_to_float_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0_0_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {state: disabled}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    comment: Look-Up Table I
    map: (-1,1)
  states: {}
- name: digital_map_bb_0_0
  id: digital_map_bb
  parameters:
    comment: Look-Up Table I
    map: (-1,1)
  states: {}
- name: digital_map_bb_0_0_0
  id: digital_map_bb
  parameters:
    comment: Look-Up Table I
    map: (-1,1)
  states: {state: disabled}
- name: note_0
  id: note
  parameters:
    note: Eve
  states: {state: disabled}
- name: note_0_0
  id: note
  parameters:
    note: Bob
  states: {}
- name: note_0_0_0
  id: note
  parameters:
    note: Alice
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    entags: 'False'
    nconnections: '3'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '256'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: alice_tx
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: bob_tx
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: eve_tx
  states: {state: disabled}
- name: virtual_sink_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: eve_tx
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: all_tx
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: alice_data
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: bob_data
  states: {}
- name: virtual_sink_1_0_0
  id: virtual_sink
  parameters:
    stream_id: eve_data
  states: {state: disabled}
- name: virtual_sink_1_0_0_0
  id: virtual_sink
  parameters:
    stream_id: eve_data
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: all_tx
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: all_tx
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: all_tx
  states: {state: disabled}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: alice_tx
  states: {}
- name: virtual_source_0_1_0
  id: virtual_source
  parameters:
    stream_id: eve_tx
  states: {}
- name: virtual_source_0_1_1
  id: virtual_source
  parameters:
    stream_id: bob_tx
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: alice_data
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: eve_data
  states: {}
- name: virtual_source_1_1
  id: virtual_source
  parameters:
    stream_id: bob_data
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://localhost:5557
    timeout: '100'
    type: byte
  states: {}
- name: zeromq_pub_sink_0_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://localhost:5559
    timeout: '100'
    type: byte
  states: {}
- name: zeromq_pub_sink_0_0_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://localhost:5561
    timeout: '100'
    type: byte
  states: {state: disabled}
- name: zeromq_sub_msg_source_0
  id: zeromq_sub_msg_source
  parameters:
    address: tcp://localhost:5555
    timeout: '100'
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://localhost:5556
    timeout: '100'
    type: byte
  states: {}
- name: zeromq_sub_source_0_0
  id: zeromq_sub_source
  parameters:
    address: tcp://localhost:5558
    timeout: '100'
    type: byte
  states: {}
- name: zeromq_sub_source_0_0_0
  id: zeromq_sub_source
  parameters:
    address: tcp://localhost:5560
    timeout: '100'
    type: byte
  states: {state: disabled}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_0, '0', virtual_sink_0_0_0_0, '0']
- [analog_sig_source_x_0_0, '0', virtual_sink_1_0_0_0, '0']
- [blocks_add_xx_0, '0', virtual_sink_0_1, '0']
- [blocks_char_to_float_0, '0', virtual_sink_0, '0']
- [blocks_char_to_float_0_0, '0', virtual_sink_0_0, '0']
- [blocks_char_to_float_0_0_0, '0', virtual_sink_0_0_0, '0']
- [blocks_delay_0, '0', zeromq_pub_sink_0, '0']
- [blocks_delay_0_0, '0', zeromq_pub_sink_0_0, '0']
- [blocks_delay_0_0_0, '0', zeromq_pub_sink_0_0_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_delay_0, '0']
- [blocks_pack_k_bits_bb_0_0, '0', blocks_delay_0_0, '0']
- [blocks_pack_k_bits_bb_0_0_0, '0', blocks_delay_0_0_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', blocks_throttle2_0, '0']
- [blocks_packed_to_unpacked_xx_0_0, '0', blocks_throttle2_0_0, '0']
- [blocks_packed_to_unpacked_xx_0_0_0, '0', blocks_throttle2_0_0_0, '0']
- [blocks_throttle2_0, '0', digital_map_bb_0, '0']
- [blocks_throttle2_0_0, '0', digital_map_bb_0_0, '0']
- [blocks_throttle2_0_0_0, '0', digital_map_bb_0_0_0, '0']
- [blocks_uchar_to_float_0_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_uchar_to_float_0_0_0, '0', qtgui_time_sink_x_0, '2']
- [blocks_uchar_to_float_0_0_1, '0', qtgui_time_sink_x_0, '1']
- [digital_binary_slicer_fb_0, '0', blocks_pack_k_bits_bb_0, '0']
- [digital_binary_slicer_fb_0_0, '0', blocks_pack_k_bits_bb_0_0, '0']
- [digital_binary_slicer_fb_0_0_0, '0', blocks_pack_k_bits_bb_0_0_0, '0']
- [digital_map_bb_0, '0', blocks_char_to_float_0, '0']
- [digital_map_bb_0_0, '0', blocks_char_to_float_0_0, '0']
- [digital_map_bb_0_0_0, '0', blocks_char_to_float_0_0_0, '0']
- [virtual_source_0, '0', digital_binary_slicer_fb_0, '0']
- [virtual_source_0_0, '0', digital_binary_slicer_fb_0_0, '0']
- [virtual_source_0_0_0, '0', digital_binary_slicer_fb_0_0_0, '0']
- [virtual_source_0_1, '0', blocks_add_xx_0, '1']
- [virtual_source_0_1_0, '0', blocks_add_xx_0, '3']
- [virtual_source_0_1_1, '0', blocks_add_xx_0, '2']
- [virtual_source_1, '0', blocks_uchar_to_float_0_0, '0']
- [virtual_source_1_0, '0', blocks_uchar_to_float_0_0_0, '0']
- [virtual_source_1_1, '0', blocks_uchar_to_float_0_0_1, '0']
- [zeromq_sub_msg_source_0, out, blocks_msgpair_to_var_0, inpair]
- [zeromq_sub_source_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [zeromq_sub_source_0, '0', virtual_sink_1, '0']
- [zeromq_sub_source_0_0, '0', blocks_packed_to_unpacked_xx_0_0, '0']
- [zeromq_sub_source_0_0, '0', virtual_sink_1_0, '0']
- [zeromq_sub_source_0_0_0, '0', blocks_packed_to_unpacked_xx_0_0_0, '0']
- [zeromq_sub_source_0_0_0, '0', virtual_sink_1_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
