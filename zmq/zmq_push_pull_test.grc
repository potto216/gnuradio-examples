options:
  parameters:
    generate_options: qt_gui
    id: default
    output_language: python
    title: zmq_push_pull_test
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: zeromq_pull_msg_source_0
  id: zeromq_pull_msg_source
  parameters:
    timeout: '100'
  states: {}
- name: zeromq_push_msg_sink_0
  id: zeromq_push_msg_sink
  parameters:
    timeout: '100'
  states: {}

connections:
- [zeromq_pull_msg_source_0, out, blocks_message_debug_0, log]
- [zeromq_pull_msg_source_0, out, blocks_message_debug_0, print]
- [zeromq_pull_msg_source_0, out, zeromq_push_msg_sink_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
