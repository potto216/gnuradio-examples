options:
  parameters:
    generate_options: qt_gui
    id: pkt_fsk_rcv_wav_v1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_FLOAT
    file: /home/user/src/gnuradio/gnuradio-examples/analysis/test_clock_recovery/packet_02_gnuradio_c02.wav
    format: FORMAT_WAV
    samp_rate: samp_rate
  states: {}

connections:
- [audio_source_0, '0', blocks_wavfile_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
