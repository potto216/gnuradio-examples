options:
  parameters:
    generate_options: qt_gui
    id: file_meta_sink
    output_language: python
    title: File Meta Sink Demo
  states: {}

blocks:
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    label: Sample Rate
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '128000'
    value: '32000'
  states: {}
- name: strobe_value
  id: variable_qtgui_chooser
  parameters:
    label: Tags strobe value
    label0: '"Stobe = 0"'
    label1: '"Stobe = 1"'
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: string
    value: '0'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '100'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: blocks_file_meta_sink_0
  id: blocks_file_meta_sink
  parameters:
    detached: 'False'
    extra_dict: pmt.dict_add(pmt.make_dict(), pmt.intern('Initial'), pmt.from_long(3))
    file: ./file/data/data_float32_saw_tooth.bin
    max_seg_size: '1000000'
    rel_rate: '1'
    samp_rate: samp_rate
    type: float
  states: {}
- name: blocks_tag_share_0
  id: blocks_tag_share
  parameters:
    io_type: float
    share_type: float
  states: {}
- name: blocks_tags_strobe_0
  id: blocks_tags_strobe
  parameters:
    key: pmt.intern("strobe")
    nsamps: int(samp_rate/100)
    type: float
    value: pmt.intern(strobe_value)
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_tag_share_0, '0']
- [blocks_tag_share_0, '0', blocks_throttle_0, '0']
- [blocks_tags_strobe_0, '0', blocks_tag_share_0, '1']
- [blocks_throttle_0, '0', blocks_file_meta_sink_0, '0']

metadata:
  file_format: 1
