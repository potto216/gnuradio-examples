options:
  parameters:
    author: Barry Duggan
    comment: 'Source: https://github.com/duggabe/gr-control/blob/main/Transmitters/pkt_fsk_xmt_rcv.grc'
    description: packet FSK xmt rcv v1
    generate_options: qt_gui
    id: pkt_fsk_xmt_rcv_v1
    output_language: python
    title: pkt_fsk_xmt_rcv_v1
  states: {}

blocks:
- name: access_key
  id: variable
  parameters:
    value: '''11100001010110101110100010010011'''
  states: {}
- name: baud
  id: variable
  parameters:
    value: '100'
  states: {}
- name: center
  id: variable
  parameters:
    value: (mark+space)/2
  states: {}
- name: decim
  id: variable
  parameters:
    value: '20'
  states: {}
- name: fsk_deviation
  id: variable
  parameters:
    value: (abs)(mark-space)
  states: {}
- name: hdr_format
  id: variable
  parameters:
    comment: header_format_default
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: inp_amp
  id: variable
  parameters:
    value: (mark/vco_max)-vco_offset
  states: {}
- name: mark
  id: variable
  parameters:
    value: '1200'
  states: {}
- name: phase_bw
  id: variable
  parameters:
    value: math.pi/32
  states: {}
- name: repeat
  id: variable
  parameters:
    value: (int)(samp_rate/baud)
  states: {}
- name: reverse
  id: variable_qtgui_chooser
  parameters:
    comment: 0,0,1,1
    gui_hint: 0,0,1,1
    label0: Normal
    label1: Reverse
    num_opts: '2'
    option0: '1'
    option1: '-1'
    type: int
    value: '-1'
    widget: radio_buttons
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: |-
      |----------------------------------------------------------------------------------------->
      User set values
    value: '44100'
  states: {}
- name: space
  id: variable
  parameters:
    value: '2200'
  states: {}
- name: sps
  id: variable
  parameters:
    value: (int)(repeat/decim)
  states: {}
- name: sq_lvl
  id: variable_qtgui_range
  parameters:
    comment: 0,1,1,1
    gui_hint: 0,1,1,1
    label: Squelch
    start: '-100'
    step: '5'
    stop: '0'
    value: '-50'
    widget: counter
  states: {}
- name: thresh
  id: variable
  parameters:
    value: '1'
  states: {}
- name: vco_max
  id: variable
  parameters:
    value: center+fsk_deviation
  states: {}
- name: vco_offset
  id: variable
  parameters:
    value: space/vco_max
  states: {}
- name: InFile
  id: parameter
  parameters:
    comment: |-
      Filename is specified on the command line, e.g.:
      python3 pkt_fsk_xmt.py --InFile="../gr-logo.png"
    label: File Name
    type: str
    value: /home/user/data/simple_file.txt
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '2.0'
    rate: '1e-4'
    reference: '1.0'
    type: float
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*fsk_deviation)
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '255'
    freq: '10'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: byte
    waveform: analog.GR_TRI_WAVE
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: sq_lvl
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    comment: vco_offset
    const: vco_offset
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: ./output.tmp
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: inp_amp
    const: inp_amp
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Normal/Reverse
    const: reverse
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_1_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_repack_bits_bb_1_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: ''
  states: {}
- name: blocks_repack_bits_bb_1_0_0
  id: blocks_repack_bits_bb
  parameters:
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: repeat
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_vco_f_0
  id: blocks_vco_f
  parameters:
    amplitude: '0.25'
    samp_rate: samp_rate
    sensitivity: 2*math.pi*vco_max
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '"11100001010110101110100010010011"'
    tagname: packet_len
    threshold: thresh
    type: byte
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_crc32_bb_0_0
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_crc_append_0
  id: digital_crc_append
  parameters:
    poly: '0x4C11DB7'
  states: {}
- name: digital_protocol_formatter_async_0
  id: digital_protocol_formatter_async
  parameters:
    format: hdr_format
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: hdr_format
    len_tag_key: '"packet_len"'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: phase_bw
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_EARLY_LATE
    type: ff
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    FileName: InFile
    Pkt_len: '75'
    _source_code: |
      """
      Embedded Python Block: File Source to Message PDUs
      """

      import numpy as np
      from gnuradio import gr
      import time
      import pmt
      import os.path
      import sys
      import base64
      import threading  # Add Python's threading module

      class blk(gr.basic_block):
          def __init__(self, FileName='None', Pkt_len=52):
              gr.basic_block.__init__(
                  self,
                  name='EPB: File Source to Message PDUs',
                  in_sig=None,
                  out_sig=None)
              
              # Define message port
              self.message_port_register_out(pmt.intern('pdus'))
              
              self.FileName = FileName
              self.Pkt_len = Pkt_len
              self.state = 0
              self.pre_count = 0
              self._debug = 0
              
              if (os.path.exists(self.FileName)):
                  # open input file
                  self.f_in = open(self.FileName, 'rb')
                  self._eof = False
                  if (self._debug):
                      print("File name:", self.FileName)
              else:
                  print(self.FileName, 'does not exist')
                  self._eof = True
                  self.state = 3

              self.char_list = [37,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85, 
                                85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85, 
                                85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85, 
                                85,85,85,93]
              self.c_len = len(self.char_list)
              
              # Start processing
              self.start()

          def send_pdu(self, data_array):
              # Convert numpy array to PMT vector
              data_pmt = pmt.init_u8vector(len(data_array), data_array)
              # Create empty metadata dictionary PMT
              meta = pmt.make_dict()
              # Create the PDU as pair of (metadata, data)
              pdu = pmt.cons(meta, data_pmt)
              # Publish the message
              self.message_port_pub(pmt.intern('pdus'), pdu)

          def start(self):
              # Use Python's threading module instead of gr.thread
              self._thread = threading.Thread(target=self.run)
              self._thread.daemon = True
              self._thread.start()
              return True

          # The rest of the code remains unchanged
          def run(self):
              while True:
                  if self.state == 0:
                      # send phasing filler
                      # delay 40 ms
                      time.sleep(0.040)
                      data = np.array(self.char_list, dtype=np.uint8)
                      self.send_pdu(data)
                      
                      self.pre_count += 1
                      if (self.pre_count > 3):
                          self.state = 1
                          
                  elif self.state == 1:
                      # Rest of the method remains unchanged
                      if not self._eof:
                          buff = self.f_in.read(self.Pkt_len)
                          b_len = len(buff)
                          if b_len == 0:
                              print('End of file')
                              self._eof = True
                              self.f_in.close()
                              self.state = 2
                              self.pre_count = 0
                          else:
                              # convert to Base64
                              encoded = base64.b64encode(buff)
                              if (self._debug):
                                  print('b64 length =', len(encoded))
                              # delay 500 ms
                              time.sleep(0.5)
                              data = np.frombuffer(encoded, dtype=np.uint8)
                              self.send_pdu(data)
                      else:
                          self.state = 2
                          
                  elif self.state == 2:
                      # send file name
                      header = np.array(self.char_list[0:8], dtype=np.uint8)
                      filename = np.array([ord(c) for c in self.FileName], dtype=np.uint8)
                      data = np.concatenate((header, filename))
                      self.send_pdu(data)
                      self.state = 3
                      
                  elif self.state == 3:
                      # send post filler
                      # delay 10 ms
                      time.sleep(0.010)
                      data = np.array(self.char_list, dtype=np.uint8)
                      self.send_pdu(data)
                      
                      self.pre_count += 1
                      if (self.pre_count > 9):
                          self.state = 4
                          
                  elif self.state == 4:
                      # delay 10 sec
                      time.sleep(10.0)
                      print("End of transmission")
                      self.state = 5
                      
                  elif self.state == 5:
                      # Finished processing, just sleep
                      time.sleep(1.0)
    comment: |-
      Filename is specified on the command line, e.g.:
      python3 pkt_fsk_xmt.py --InFile="../gr-logo.png"
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    FileName: InFile
    Pkt_len: '10'
    _source_code: "\"\"\"\nEmbedded Python Block: File Source to Tagged Stream\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport time\nimport pmt\nimport os.path\nimport sys\nimport base64\n\nclass blk(gr.sync_block):\n    def __init__(self, FileName='None', Pkt_len=52):\n        gr.sync_block.__init__(\n            self,\n            name='EPB: File Source to Tagged Stream',\n            in_sig=None,\n            out_sig=[np.uint8])\n        self.FileName = FileName\n        self.Pkt_len = Pkt_len\n        self.state = 0\n        self.pre_count = 0\n        self.indx = 0\n        self._debug = 0\n        if (os.path.exists(self.FileName)):\n            # open input file\n            self.f_in = open (self.FileName, 'rb')\n            self._eof = False\n            if (self._debug):\n                print (\"File name:\", self.FileName)\n        else:\n            print(self.FileName, 'does not exist')\n            self._eof = True\n            self.state = 3\n\n        self.char_list = [37,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85, 85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85, 85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85, 85,85,85,93]\n        self.c_len = len (self.char_list)\n        # print (self.c_len)\n\n    def work(self, input_items, output_items):\n        if (self.state == 0):\n            # send phasing filler\n            # delay 40 ms\n            ##time.sleep (0.040)\n            key1 = pmt.intern(\"packet_len\")\n            val1 = pmt.from_long(self.c_len)\n            self.add_item_tag(0, # Write to output port 0\n                self.indx,   # Index of the tag\n                key1,   # Key of the tag\n                val1    # Value of the tag\n                )\n            self.indx += self.c_len\n            i = 0\n            while (i < self.c_len):\n                output_items[0][i] = self.char_list[i]\n                i += 1\n            self.pre_count += 1\n            if (self.pre_count > 3):\n                self.state = 1\n            return (self.c_len)\n        elif (self.state == 1):\n            while (not (self._eof)):\n                buff = self.f_in.read (self.Pkt_len)\n                b_len = len(buff)\n                if b_len == 0:\n                    print ('End of file')\n                    self._eof = True\n                    self.f_in.close()\n                    self.state = 2\n                    self.pre_count = 0\n                    break\n                # convert to Base64\n                encoded = base64.b64encode (buff)\n                e_len = len(encoded)\n                if (self._debug):\n                    print ('b64 length =', e_len)\n                # delay 500 ms\n                ##time.sleep (0.5)\n                key0 = pmt.intern(\"packet_len\")\n                val0 = pmt.from_long(e_len)\n                self.add_item_tag(0, # Write to output port 0\n                    self.indx,   # Index of the tag\n                    key0,   # Key of the tag\n                    val0    # Value of the tag\n                    )\n                self.indx += e_len\n                i = 0\n                while (i < e_len):\n                    output_items[0][i] = encoded[i]\n                    i += 1\n                return (e_len)\n        elif (self.state == 2):\n            # send file name\n            fn_len = len (self.FileName)\n            key1 = pmt.intern(\"packet_len\")\n            val1 = pmt.from_long(fn_len+8)\n            self.add_item_tag(0, # Write to output port 0\n                self.indx,   # Index of the tag\n                key1,   # Key of the tag\n                val1    # Value of the tag\n                )\n            self.indx += (fn_len+8)\n            i = 0\n            while (i < 8):\n                output_items[0][i] = self.char_list[i]\n                i += 1\n            j = 0\n            while (i < (fn_len+8)):\n                output_items[0][i] = ord(self.FileName[j])\n                i += 1\n                j += 1\n            self.state = 3\n            return (fn_len+8)\n        elif (self.state == 3):\n            # send post filler\n            # delay 10 ms\n            ##time.sleep (0.010)\n            key1 = pmt.intern(\"packet_len\")\n            val1 = pmt.from_long(self.c_len)\n            self.add_item_tag(0, # Write to output port 0\n                self.indx,   # Index of the tag\n                key1,   # Key of the tag\n                val1    # Value of the tag\n                )\n            self.indx += self.c_len\n            i = 0\n            while (i < self.c_len):\n                output_items[0][i] = self.char_list[i]\n                i += 1\n            self.pre_count += 1\n            if (self.pre_count > 9):\n                self.state = 4\n            return (self.c_len)\n        elif (self.state == 4):\n            # delay 10 sec\n           ## time.sleep (10.0)\n            print (\"End of transmission\")\n            self.state = 5\n            return (0)\n        return (0)\n\n"
    comment: |-
      Filename is specified on the command line, e.g.:
      python3 pkt_fsk_xmt.py --InFile="../gr-logo.png"
  states: {}
- name: epy_block_0_1
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\nimport pmt\n\nclass msg_injector(gr.sync_block):\n    def __init__(self):\n        gr.sync_block.__init__(\n            self,\n            name='Message Injector',\n            in_sig=[np.float32],   # Now accepts a continuous float stream as input\n            out_sig=[np.float32],\n        )\n        # Register the message input port.\n        self.message_port_register_in(pmt.intern(\"in\"))\n        self.set_msg_handler(pmt.intern(\"in\"), self.handle_msg)\n        # Buffer to hold injected message payload samples.\n        self.buffer = np.array([], dtype=np.float32)\n\n    def handle_msg(self, msg):\n        # Check that msg is a pair (dict, payload)\n        if pmt.is_pair(msg):\n            payload = pmt.cdr(msg)\n            # Convert the PMT payload to a Python list.\n            # This assumes the payload was created as a PMT float vector.\n            data = np.array(pmt.to_python(payload), dtype=np.float32)\n            # Append the new message data to the current buffer.\n            self.buffer = np.concatenate([self.buffer, data])\n\n    def work(self, input_items, output_items):\n        # Get the continuous input stream.\n        in0 = input_items[0]\n        out = output_items[0]\n        num_output_items = len(out)\n\n        # Start by copying the input stream to output.\n        out[:] = in0[:num_output_items]\n\n        # If we have any message data buffered, add it onto the first samples.\n        if self.buffer.size > 0:\n            n = min(num_output_items, self.buffer.size)\n            out[:n] += self.buffer[:n]\n            # Remove the consumed samples from the buffer.\n            self.buffer = self.buffer[n:]\n\n        return num_output_items\n\n"
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: center
    decim: decim
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0,samp_rate,2000,400)
    type: fcf
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      |----------------------------------------------------------------------------------------------------------------------------------------------------------|
      Calculated values:
      -   center freq = (mark+space)/2
      -   repeat = (int)(samp_rate/baud)
      -   fsk_deviation = (abs)(mark-space)
      -   vco_max = center+fsk_deviation
      -   vco_offset = space/vco_max
      -   inp_amp = (mark/vco_max)-vco_offset
      -   vco sensitivity = 2*math.pi*vco_max
  states: {}
- name: note_0_0
  id: note
  parameters:
    comment: |-
      |----------------------------------------------------------------------------------------->
      Calculated values:
      -   sps = (int)(repeat/decim)
      -  decim = 
      -   Quad Demod Gain = samp_rate/(2*math.pi*fsk_deviation)
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Header
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Payload
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    comment: 1,0,1,3
    gui_hint: 1,0,1,3
    label1: ''
    name: Transmit data
    size: '2048'
    srate: samp_rate
    tr_delay: '0.0'
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_NORM
    tr_tag: '"packet_len"'
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    comment: 3,0,1,3
    gui_hint: 3,0,1,3
    label1: ''
    name: Correlate Output
    size: '128'
    srate: samp_rate
    tr_delay: '0.0'
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_2
  id: qtgui_time_sink_x
  parameters:
    comment: 2,0,1,3
    gui_hint: 2,0,1,3
    label1: ''
    name: Correlate input
    size: '128'
    srate: samp_rate
    tr_delay: '0.0'
    tr_level: '0.2'
    tr_tag: '"packet_len"'
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    label1: TX
    label2: RX
    name: TX/RX
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    nconnections: '4'
    size: sps*10
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '512'
    int_min: '-60'
    name: TX
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    int_min: '-60'
    name: RX
    type: complex
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: t2
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: t1
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: r1
  states: {}
- name: virtual_sink_0_0_1
  id: virtual_sink
  parameters:
    stream_id: t1
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: t1
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: t2
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: t1
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: r1
  states: {}

connections:
- [analog_agc_xx_0, '0', digital_symbol_sync_xx_0, '0']
- [analog_quadrature_demod_cf_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [analog_sig_source_x_0, '0', virtual_sink_0_0_1, '0']
- [analog_simple_squelch_cc_0, '0', analog_quadrature_demod_cf_0, '0']
- [analog_simple_squelch_cc_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [audio_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [audio_source_0, '0', qtgui_time_sink_x_1, '1']
- [blocks_add_const_vxx_0, '0', blocks_vco_f_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', analog_agc_xx_0, '0']
- [blocks_repack_bits_bb_1_0, '0', blocks_repeat_0, '0']
- [blocks_repack_bits_bb_1_0_0, '0', digital_crc32_bb_0_0, '0']
- [blocks_repeat_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_tagged_stream_mux_0, '0', blocks_null_sink_0_0, '0']
- [blocks_tagged_stream_mux_0, '0', virtual_sink_0_0, '0']
- [blocks_tagged_stream_mux_0_0, '0', blocks_null_sink_0, '0']
- [blocks_tagged_stream_mux_0_0, '0', virtual_sink_0_1, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_uchar_to_float_0, '0', virtual_sink_0, '0']
- [blocks_uchar_to_float_0_0, '0', blocks_null_sink_1_1, '0']
- [blocks_uchar_to_float_0_0, '0', qtgui_time_sink_x_0_2, '0']
- [blocks_uchar_to_float_0_0_0, '0', blocks_null_sink_1, '0']
- [blocks_uchar_to_float_0_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_vco_f_0, '0', audio_sink_0, '0']
- [blocks_vco_f_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_vco_f_0, '0', qtgui_waterfall_sink_x_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_uchar_to_float_0_0, '0']
- [digital_binary_slicer_fb_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_repack_bits_bb_1_0_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_uchar_to_float_0_0_0, '0']
- [digital_crc32_bb_0, '0', blocks_tagged_stream_mux_0, '1']
- [digital_crc32_bb_0, '0', digital_protocol_formatter_bb_0, '0']
- [digital_crc32_bb_0_0, '0', blocks_file_sink_0, '0']
- [digital_crc_append_0, out, digital_protocol_formatter_async_0, in]
- [digital_protocol_formatter_async_0, header, pdu_pdu_to_tagged_stream_0, pdus]
- [digital_protocol_formatter_async_0, payload, pdu_pdu_to_tagged_stream_0_0, pdus]
- [digital_protocol_formatter_bb_0, '0', blocks_tagged_stream_mux_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_time_sink_x_2, '0']
- [digital_symbol_sync_xx_0, '0', virtual_sink_0_0_0, '0']
- [digital_symbol_sync_xx_0, '1', qtgui_time_sink_x_2, '1']
- [digital_symbol_sync_xx_0, '2', qtgui_time_sink_x_2, '2']
- [digital_symbol_sync_xx_0, '3', qtgui_time_sink_x_2, '3']
- [epy_block_0, pdus, digital_crc_append_0, in]
- [epy_block_0_0, '0', digital_crc32_bb_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_simple_squelch_cc_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_tagged_stream_mux_0_0, '0']
- [pdu_pdu_to_tagged_stream_0_0, '0', blocks_tagged_stream_mux_0_0, '1']
- [virtual_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [virtual_source_0_0, '0', blocks_repack_bits_bb_1_0, '0']
- [virtual_source_2, '0', digital_binary_slicer_fb_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
