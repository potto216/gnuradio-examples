options:
  parameters:
    author: Barry Duggan
    comment: 'Source: https://github.com/duggabe/gr-control/blob/main/Transmitters/pkt_fsk_xmt_rcv.grc'
    description: packet FSK xmt rcv v1
    generate_options: qt_gui
    id: pkt_fsk_xmt_rcv_v1
    output_language: python
    title: pkt_fsk_xmt_rcv_v1
  states: {}

blocks:
- name: access_key
  id: variable
  parameters:
    value: '''11100001010110101110100010010011'''
  states: {}
- name: baud
  id: variable
  parameters:
    value: '100'
  states: {}
- name: center
  id: variable
  parameters:
    value: (mark+space)/2
  states: {}
- name: decim
  id: variable
  parameters:
    value: '20'
  states: {}
- name: fsk_deviation
  id: variable
  parameters:
    value: (abs)(mark-space)
  states: {}
- name: hdr_format
  id: variable
  parameters:
    comment: header_format_default
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: inp_amp
  id: variable
  parameters:
    value: (mark/vco_max)-vco_offset
  states: {}
- name: mark
  id: variable
  parameters:
    value: '1200'
  states: {}
- name: phase_bw
  id: variable
  parameters:
    value: math.pi/32
  states: {}
- name: repeat
  id: variable
  parameters:
    value: (int)(samp_rate/baud)
  states: {}
- name: reverse
  id: variable_qtgui_chooser
  parameters:
    comment: 0,0,1,1
    gui_hint: 0,0,1,1
    label0: Normal
    label1: Reverse
    num_opts: '2'
    option0: '1'
    option1: '-1'
    type: int
    value: '-1'
    widget: radio_buttons
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: |-
      |----------------------------------------------------------------------------------------->
      User set values
    value: '44100'
  states: {}
- name: space
  id: variable
  parameters:
    value: '2200'
  states: {}
- name: sps
  id: variable
  parameters:
    value: (int)(repeat/decim)
  states: {}
- name: sq_lvl
  id: variable_qtgui_range
  parameters:
    comment: 0,1,1,1
    gui_hint: 0,1,1,1
    label: Squelch
    start: '-100'
    step: '5'
    stop: '0'
    value: '-50'
    widget: counter
  states: {}
- name: thresh
  id: variable
  parameters:
    value: '1'
  states: {}
- name: vco_max
  id: variable
  parameters:
    value: center+fsk_deviation
  states: {}
- name: vco_offset
  id: variable
  parameters:
    value: space/vco_max
  states: {}
- name: InFile
  id: parameter
  parameters:
    comment: |-
      Filename is specified on the command line, e.g.:
      python3 pkt_fsk_xmt.py --InFile="../gr-logo.png"
    label: File Name
    type: str
    value: /home/user/data/simple_file.txt
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    comment: vco_offset
    const: vco_offset
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: inp_amp
    const: inp_amp
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_repack_bits_bb_1_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: ''
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: repeat
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_vco_f_0
  id: blocks_vco_f
  parameters:
    amplitude: '0.25'
    samp_rate: samp_rate
    sensitivity: 2*math.pi*vco_max
  states: {}
- name: digital_crc_append_0
  id: digital_crc_append
  parameters:
    poly: '0x4C11DB7'
  states: {}
- name: digital_protocol_formatter_async_0
  id: digital_protocol_formatter_async
  parameters:
    format: hdr_format
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    FileName: InFile
    Pkt_len: '75'
    _source_code: |
      """
      Embedded Python Block: File Source to Message PDUs
      """

      import numpy as np
      from gnuradio import gr
      import time
      import pmt
      import os.path
      import sys
      import base64
      import threading  # Add Python's threading module

      class blk(gr.basic_block):
          def __init__(self, FileName='None', Pkt_len=52):
              gr.basic_block.__init__(
                  self,
                  name='EPB: File Source to Message PDUs',
                  in_sig=None,
                  out_sig=None)
              
              # Define message port
              self.message_port_register_out(pmt.intern('pdus'))
              
              self.FileName = FileName
              self.Pkt_len = Pkt_len
              self.state = 0
              self.pre_count = 0
              self._debug = 0
              
              if (os.path.exists(self.FileName)):
                  # open input file
                  self.f_in = open(self.FileName, 'rb')
                  self._eof = False
                  if (self._debug):
                      print("File name:", self.FileName)
              else:
                  print(self.FileName, 'does not exist')
                  self._eof = True
                  self.state = 3

              self.char_list = [37,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85, 
                                85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85, 
                                85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85, 
                                85,85,85,93]
              self.c_len = len(self.char_list)
              
              # Start processing
              self.start()

          def send_pdu(self, data_array):
              # Convert numpy array to PMT vector
              data_pmt = pmt.init_u8vector(len(data_array), data_array)
              # Create empty metadata dictionary PMT
              meta = pmt.make_dict()
              # Create the PDU as pair of (metadata, data)
              pdu = pmt.cons(meta, data_pmt)
              # Publish the message
              self.message_port_pub(pmt.intern('pdus'), pdu)

          def start(self):
              # Use Python's threading module instead of gr.thread
              self._thread = threading.Thread(target=self.run)
              self._thread.daemon = True
              self._thread.start()
              return True

          # The rest of the code remains unchanged
          def run(self):
              while True:
                  if self.state == 0:
                      # send phasing filler
                      # delay 40 ms
                      time.sleep(0.040)
                      data = np.array(self.char_list, dtype=np.uint8)
                      self.send_pdu(data)
                      
                      self.pre_count += 1
                      if (self.pre_count > 3):
                          self.state = 1
                          
                  elif self.state == 1:
                      # Rest of the method remains unchanged
                      if not self._eof:
                          buff = self.f_in.read(self.Pkt_len)
                          b_len = len(buff)
                          if b_len == 0:
                              print('End of file')
                              self._eof = True
                              self.f_in.close()
                              self.state = 2
                              self.pre_count = 0
                          else:
                              # convert to Base64
                              encoded = base64.b64encode(buff)
                              if (self._debug):
                                  print('b64 length =', len(encoded))
                              # delay 500 ms
                              time.sleep(0.5)
                              data = np.frombuffer(encoded, dtype=np.uint8)
                              self.send_pdu(data)
                      else:
                          self.state = 2
                          
                  elif self.state == 2:
                      # send file name
                      header = np.array(self.char_list[0:8], dtype=np.uint8)
                      filename = np.array([ord(c) for c in self.FileName], dtype=np.uint8)
                      data = np.concatenate((header, filename))
                      self.send_pdu(data)
                      self.state = 3
                      
                  elif self.state == 3:
                      # send post filler
                      # delay 10 ms
                      time.sleep(0.010)
                      data = np.array(self.char_list, dtype=np.uint8)
                      self.send_pdu(data)
                      
                      self.pre_count += 1
                      if (self.pre_count > 9):
                          self.state = 4
                          
                  elif self.state == 4:
                      # delay 10 sec
                      time.sleep(10.0)
                      print("End of transmission")
                      self.state = 5
                      
                  elif self.state == 5:
                      # Finished processing, just sleep
                      time.sleep(1.0)
    comment: |-
      Filename is specified on the command line, e.g.:
      python3 pkt_fsk_xmt.py --InFile="../gr-logo.png"
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      |----------------------------------------------------------------------------------------------------------------------------------------------------------|
      Calculated values:
      -   center freq = (mark+space)/2
      -   repeat = (int)(samp_rate/baud)
      -   fsk_deviation = (abs)(mark-space)
      -   vco_max = center+fsk_deviation
      -   vco_offset = space/vco_max
      -   inp_amp = (mark/vco_max)-vco_offset
      -   vco sensitivity = 2*math.pi*vco_max
  states: {}
- name: note_0_0
  id: note
  parameters:
    comment: |-
      |----------------------------------------------------------------------------------------->
      Calculated values:
      -   sps = (int)(repeat/decim)
      -  decim = 
      -   Quad Demod Gain = samp_rate/(2*math.pi*fsk_deviation)
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Header
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Payload
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '512'
    int_min: '-60'
    name: TX
    type: float
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: t2
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: t1
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: t2
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: t1
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', blocks_vco_f_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_repack_bits_bb_1_0, '0', blocks_repeat_0, '0']
- [blocks_repeat_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_tagged_stream_mux_0_0, '0', blocks_null_sink_0, '0']
- [blocks_tagged_stream_mux_0_0, '0', virtual_sink_0_1, '0']
- [blocks_uchar_to_float_0, '0', virtual_sink_0, '0']
- [blocks_vco_f_0, '0', audio_sink_0, '0']
- [blocks_vco_f_0, '0', qtgui_waterfall_sink_x_0, '0']
- [digital_crc_append_0, out, digital_protocol_formatter_async_0, in]
- [digital_protocol_formatter_async_0, header, pdu_pdu_to_tagged_stream_0, pdus]
- [digital_protocol_formatter_async_0, payload, pdu_pdu_to_tagged_stream_0_0, pdus]
- [epy_block_0, pdus, digital_crc_append_0, in]
- [pdu_pdu_to_tagged_stream_0, '0', blocks_tagged_stream_mux_0_0, '0']
- [pdu_pdu_to_tagged_stream_0_0, '0', blocks_tagged_stream_mux_0_0, '1']
- [virtual_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [virtual_source_0_0, '0', blocks_repack_bits_bb_1_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
