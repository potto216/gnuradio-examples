options:
  parameters:
    author: Barry Duggan
    comment: 'Source: https://github.com/duggabe/gr-control/blob/main/Transmitters/pkt_fsk_xmt_rcv.grc'
    description: packet FSK xmt rcv v1
    generate_options: qt_gui
    id: pkt_fsk_xmt_rcv_v1
    output_language: python
    title: pkt_fsk_xmt_rcv_v1
  states: {}

blocks:
- name: access_key
  id: variable
  parameters:
    value: '''11100001010110101110100010010011'''
  states: {}
- name: baud
  id: variable
  parameters:
    value: '100'
  states: {}
- name: center
  id: variable
  parameters:
    value: (mark+space)/2
  states: {}
- name: decim
  id: variable
  parameters:
    value: '20'
  states: {}
- name: fsk_deviation
  id: variable
  parameters:
    value: (abs)(mark-space)
  states: {}
- name: hdr_format
  id: variable
  parameters:
    comment: header_format_default
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: inp_amp
  id: variable
  parameters:
    value: (mark/vco_max)-vco_offset
  states: {}
- name: mark
  id: variable
  parameters:
    value: '1200'
  states: {}
- name: phase_bw
  id: variable
  parameters:
    value: math.pi/32
  states: {}
- name: repeat
  id: variable
  parameters:
    value: (int)(samp_rate/baud)
  states: {}
- name: reverse
  id: variable_qtgui_chooser
  parameters:
    comment: 0,0,1,1
    gui_hint: 0,0,1,1
    label0: Normal
    label1: Reverse
    num_opts: '2'
    option0: '1'
    option1: '-1'
    type: int
    value: '-1'
    widget: radio_buttons
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: |-
      |----------------------------------------------------------------------------------------->
      User set values
    value: '44100'
  states: {}
- name: space
  id: variable
  parameters:
    value: '2200'
  states: {}
- name: sps
  id: variable
  parameters:
    value: (int)(repeat/decim)
  states: {}
- name: sq_lvl
  id: variable_qtgui_range
  parameters:
    comment: 0,1,1,1
    gui_hint: 0,1,1,1
    label: Squelch
    start: '-100'
    step: '5'
    stop: '0'
    value: '-50'
    widget: counter
  states: {}
- name: thresh
  id: variable
  parameters:
    value: '1'
  states: {}
- name: vco_max
  id: variable
  parameters:
    value: center+fsk_deviation
  states: {}
- name: vco_offset
  id: variable
  parameters:
    value: space/vco_max
  states: {}
- name: InFile
  id: parameter
  parameters:
    comment: |-
      Filename is specified on the command line, e.g.:
      python3 pkt_fsk_xmt.py --InFile="../gr-logo.png"
    label: File Name
    type: str
    value: /home/user/data/simple_file.txt
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '2.0'
    rate: '1e-4'
    reference: '1.0'
    type: float
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*fsk_deviation)
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: sq_lvl
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: ./output.tmp
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Normal/Reverse
    const: reverse
    type: float
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_1_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_repack_bits_bb_1_0_0
  id: blocks_repack_bits_bb
  parameters:
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_uchar_to_float_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '"11100001010110101110100010010011"'
    tagname: packet_len
    threshold: thresh
    type: byte
  states: {}
- name: digital_crc32_bb_0_0
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: phase_bw
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_EARLY_LATE
    type: ff
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: center
    decim: decim
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0,samp_rate,2000,400)
    type: fcf
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      |----------------------------------------------------------------------------------------------------------------------------------------------------------|
      Calculated values:
      -   center freq = (mark+space)/2
      -   repeat = (int)(samp_rate/baud)
      -   fsk_deviation = (abs)(mark-space)
      -   vco_max = center+fsk_deviation
      -   vco_offset = space/vco_max
      -   inp_amp = (mark/vco_max)-vco_offset
      -   vco sensitivity = 2*math.pi*vco_max
  states: {}
- name: note_0_0
  id: note
  parameters:
    comment: |-
      |----------------------------------------------------------------------------------------->
      Calculated values:
      -   sps = (int)(repeat/decim)
      -  decim = 
      -   Quad Demod Gain = samp_rate/(2*math.pi*fsk_deviation)
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    comment: 3,0,1,3
    gui_hint: 3,0,1,3
    label1: ''
    name: Correlate Output
    size: '128'
    srate: samp_rate
    tr_delay: '0.0'
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_2
  id: qtgui_time_sink_x
  parameters:
    comment: 2,0,1,3
    gui_hint: 2,0,1,3
    label1: ''
    name: Correlate input
    size: '128'
    srate: samp_rate
    tr_delay: '0.0'
    tr_level: '0.2'
    tr_tag: '"packet_len"'
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {state: disabled}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    nconnections: '4'
    size: sps*10
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    int_min: '-60'
    name: RX
    type: complex
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: r1
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: r1
  states: {}

connections:
- [analog_agc_xx_0, '0', digital_symbol_sync_xx_0, '0']
- [analog_quadrature_demod_cf_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_quadrature_demod_cf_0, '0']
- [analog_simple_squelch_cc_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [audio_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', analog_agc_xx_0, '0']
- [blocks_repack_bits_bb_1_0_0, '0', digital_crc32_bb_0_0, '0']
- [blocks_uchar_to_float_0_0, '0', blocks_null_sink_1_1, '0']
- [blocks_uchar_to_float_0_0, '0', qtgui_time_sink_x_0_2, '0']
- [blocks_uchar_to_float_0_0_0, '0', blocks_null_sink_1, '0']
- [blocks_uchar_to_float_0_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_uchar_to_float_0_0, '0']
- [digital_binary_slicer_fb_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_repack_bits_bb_1_0_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_uchar_to_float_0_0_0, '0']
- [digital_crc32_bb_0_0, '0', blocks_file_sink_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_time_sink_x_2, '0']
- [digital_symbol_sync_xx_0, '0', virtual_sink_0_0_0, '0']
- [digital_symbol_sync_xx_0, '1', qtgui_time_sink_x_2, '1']
- [digital_symbol_sync_xx_0, '2', qtgui_time_sink_x_2, '2']
- [digital_symbol_sync_xx_0, '3', qtgui_time_sink_x_2, '3']
- [freq_xlating_fir_filter_xxx_0, '0', analog_simple_squelch_cc_0, '0']
- [virtual_source_2, '0', digital_binary_slicer_fb_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
